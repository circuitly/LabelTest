File: LabelTest.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: cool
Other:
- company: Circuitly, Inc. -> (none)
- title: Global/Net Label orientation tests -> (none)
